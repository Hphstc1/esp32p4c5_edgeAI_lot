/*
 * jpeg_annotate implementation.
 *
 * 5x7 font table covers 0-9, A-Z, a-z, space, '-', '_', ':' — everything
 * the FaceHit serialiser produces. Other bytes render as '?'.
 */
#include "jpeg_annotate.hpp"
#include "face_ai.hpp"

#include <cstring>

namespace p4fs {
namespace draw {

static inline void putpx(uint8_t *buf, int w, int h, int x, int y, uint16_t c) {
    if ((unsigned)x >= (unsigned)w || (unsigned)y >= (unsigned)h) return;
    uint16_t *p = (uint16_t *)(buf + (y * w + x) * 2);
    *p = c;
}

void hline(uint8_t *buf, int w, int h, int x, int y, int len, uint16_t c) {
    for (int i = 0; i < len; i++) putpx(buf, w, h, x + i, y, c);
}

void vline(uint8_t *buf, int w, int h, int x, int y, int len, uint16_t c) {
    for (int i = 0; i < len; i++) putpx(buf, w, h, x, y + i, c);
}

void rect(uint8_t *buf, int w, int h, int x, int y, int rw, int rh, int t, uint16_t c) {
    if (t < 1) t = 1;
    hline(buf, w, h, x,         y,         rw, c);
    hline(buf, w, h, x,         y + rh - 1, rw, c);
    vline(buf, w, h, x,         y,         rh, c);
    vline(buf, w, h, x + rw - 1, y,         rh, c);
    if (t > 1) {
        hline(buf, w, h, x + 1,     y + 1,         rw - 2, c);
        hline(buf, w, h, x + 1,     y + rh - 2,    rw - 2, c);
        vline(buf, w, h, x + 1,     y + 1,         rh - 2, c);
        vline(buf, w, h, x + rw - 2, y + 1,         rh - 2, c);
    }
}

void fill_rect(uint8_t *buf, int w, int h, int x, int y, int rw, int rh, uint16_t c) {
    for (int j = 0; j < rh; j++) {
        for (int i = 0; i < rw; i++) {
            putpx(buf, w, h, x + i, y + j, c);
        }
    }
}

// ---- 5x7 font --------------------------------------------------------
// One bit per pixel, 5 columns × 7 rows, MSB = top row.
static const uint8_t kFont5x7[96][5] = {
    // 0..9
    {0x3E,0x51,0x49,0x45,0x3E}, // 0
    {0x00,0x42,0x7F,0x40,0x00}, // 1
    {0x42,0x61,0x51,0x49,0x46}, // 2
    {0x21,0x41,0x45,0x4B,0x31}, // 3
    {0x18,0x14,0x12,0x7F,0x10}, // 4
    {0x27,0x45,0x45,0x45,0x39}, // 5
    {0x3C,0x4A,0x49,0x49,0x30}, // 6
    {0x01,0x71,0x09,0x05,0x03}, // 7
    {0x36,0x49,0x49,0x49,0x36}, // 8
    {0x06,0x49,0x49,0x29,0x1E}, // 9
    // : ; < = > ? @
    {0x00,0x36,0x36,0x00,0x00}, // :
    {0x00,0x00,0x00,0x00,0x00}, // placeholder
    {0x00,0x00,0x00,0x00,0x00},
    {0x00,0x14,0x14,0x14,0x00}, // =
    {0x00,0x00,0x00,0x00,0x00},
    {0x02,0x01,0x51,0x09,0x06}, // ?
    {0x32,0x49,0x79,0x41,0x3E}, // @
    // A..Z
    {0x7E,0x11,0x11,0x11,0x7E}, // A
    {0x7F,0x49,0x49,0x49,0x36}, // B
    {0x3E,0x41,0x41,0x41,0x22}, // C
    {0x7F,0x41,0x41,0x22,0x1C}, // D
    {0x7F,0x49,0x49,0x49,0x41}, // E
    {0x7F,0x09,0x09,0x09,0x01}, // F
    {0x3E,0x41,0x49,0x49,0x7A}, // G
    {0x7F,0x08,0x08,0x08,0x7F}, // H
    {0x00,0x41,0x7F,0x41,0x00}, // I
    {0x20,0x40,0x41,0x3F,0x01}, // J
    {0x7F,0x08,0x14,0x22,0x41}, // K
    {0x7F,0x40,0x40,0x40,0x40}, // L
    {0x7F,0x02,0x04,0x02,0x7F}, // M
    {0x7F,0x04,0x08,0x10,0x7F}, // N
    {0x3E,0x41,0x41,0x41,0x3E}, // O
    {0x7F,0x09,0x09,0x09,0x06}, // P
    {0x3E,0x41,0x51,0x21,0x5E}, // Q
    {0x7F,0x09,0x19,0x29,0x46}, // R
    {0x46,0x49,0x49,0x49,0x31}, // S
    {0x01,0x01,0x7F,0x01,0x01}, // T
    {0x3F,0x40,0x40,0x40,0x3F}, // U
    {0x1F,0x20,0x40,0x20,0x1F}, // V
    {0x3F,0x40,0x38,0x40,0x3F}, // W
    {0x63,0x14,0x08,0x14,0x63}, // X
    {0x07,0x08,0x70,0x08,0x07}, // Y
    {0x61,0x51,0x49,0x45,0x43}, // Z
    // [ \ ] ^ _ `
    {0x00,0x00,0x7F,0x41,0x41}, // [
    {0x02,0x04,0x08,0x10,0x20}, // backslash
    {0x41,0x41,0x7F,0x00,0x00}, // ]
    {0x04,0x02,0x01,0x02,0x04}, // ^
    {0x40,0x40,0x40,0x40,0x40}, // _
    {0x00,0x01,0x02,0x04,0x00}, // `
    // a..z
    {0x20,0x54,0x54,0x54,0x78}, // a
    {0x7F,0x48,0x44,0x44,0x38}, // b
    {0x38,0x44,0x44,0x44,0x20}, // c
    {0x38,0x44,0x44,0x48,0x7F}, // d
    {0x38,0x54,0x54,0x54,0x18}, // e
    {0x08,0x7E,0x09,0x01,0x02}, // f
    {0x0C,0x52,0x52,0x52,0x3E}, // g
    {0x7F,0x08,0x04,0x04,0x78}, // h
    {0x00,0x44,0x7D,0x40,0x00}, // i
    {0x20,0x40,0x44,0x3D,0x00}, // j
    {0x00,0x7F,0x10,0x28,0x44}, // k
    {0x00,0x41,0x7F,0x40,0x00}, // l
    {0x7C,0x04,0x18,0x04,0x78}, // m
    {0x7C,0x08,0x04,0x04,0x78}, // n
    {0x38,0x44,0x44,0x44,0x38}, // o
    {0x7C,0x14,0x14,0x14,0x08}, // p
    {0x08,0x14,0x14,0x18,0x7C}, // q
    {0x7C,0x08,0x04,0x04,0x08}, // r
    {0x48,0x54,0x54,0x54,0x20}, // s
    {0x04,0x3F,0x44,0x40,0x20}, // t
    {0x3C,0x40,0x40,0x20,0x7C}, // u
    {0x1C,0x20,0x40,0x20,0x1C}, // v
    {0x3C,0x40,0x30,0x40,0x3C}, // w
    {0x44,0x28,0x10,0x28,0x44}, // x
    {0x0C,0x50,0x50,0x50,0x3C}, // y
    {0x44,0x64,0x54,0x4C,0x44}, // z
    // { | } ~ DEL
    {0x00,0x08,0x36,0x41,0x00}, // {
    {0x00,0x00,0x7F,0x00,0x00}, // |
    {0x00,0x41,0x36,0x08,0x00}, // }
    {0x30,0x08,0x08,0x08,0x30}, // ~
    {0x00,0x00,0x00,0x00,0x00}, // DEL
};

static const uint8_t *glyph_for(char c) {
    if (c >= 0x20 && c <= 0x7E) return kFont5x7[c - 0x20];
    return kFont5x7['?' - 0x20];
}

int text_5x7(uint8_t *buf, int w, int h, int x, int y,
             const char *s, uint16_t fg, uint16_t bg) {
    if (!s) return 0;
    int drawn = 0;
    int cx = x;
    int cell_w = 6; // 5 px + 1 px gap
    int len = (int)std::strlen(s);
    for (int i = 0; i < len; i++) {
        const uint8_t *g = glyph_for(s[i]);
        // Optional background patch — keeps the label readable on busy frames.
        if (bg != fg) fill_rect(buf, w, h, cx, y, 5, 7, bg);
        for (int col = 0; col < 5; col++) {
            uint8_t bits = g[col];
            for (int row = 0; row < 7; row++) {
                if (bits & (1 << row)) putpx(buf, w, h, cx + col, y + row, fg);
            }
        }
        cx += cell_w;
        drawn += cell_w;
    }
    return drawn;
}

static void label_for(const FaceHit &hit, char *out, size_t n) {
    if (hit.id >= 0) {
        std::snprintf(out, n, "%s sim=%.2f", hit.name.c_str(), hit.sim);
    } else {
        std::snprintf(out, n, "unknown %.2f", hit.score);
    }
}

void annotate_faces(uint8_t *rgb565, int w, int h,
                    const std::vector<FaceHit> &hits) {
    for (const auto &hit : hits) {
        uint16_t col = (hit.id >= 0) ? p4fs::draw::rgb565(0, 255, 0)
                                     : p4fs::draw::rgb565(255, 64, 0);
        rect(rgb565, w, h, hit.x, hit.y, hit.w, hit.h, 2, col);

        char lbl[64];
        label_for(hit, lbl, sizeof(lbl));
        int lbl_w = (int)std::strlen(lbl) * 6;
        int tx = hit.x;
        int ty = hit.y - 9;
        if (ty < 0) ty = hit.y + hit.h + 1;
        if (tx + lbl_w > w) tx = w - lbl_w - 1;
        if (tx < 0) tx = 0;
        text_5x7(rgb565, w, h, tx, ty, lbl,
                 (uint16_t)p4fs::draw::rgb565(255, 255, 255), col);
    }
}

} // namespace draw
} // namespace p4fs
